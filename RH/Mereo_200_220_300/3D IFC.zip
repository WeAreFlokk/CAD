Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-18T01:20:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 18 01:20:25 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{A972CA98-D836-4225-BF7D-696BEC3A04BA}\ifc * Database version: 5507 * Database creation date: Tue Dec 18 01:20:24 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 18 01:20:24 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 18 01:20:24 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Mereo 200 Silver, CONV_Flokk_OffcChrs_RHMereo200:Mereo 200 Silver:315454
In: Level 1
Material: Plastic, Opaque Black, Silver Metal, Steelcut Trio 1652
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Flokk
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.6473 m2; Volume: 0.39897 m3
Materials and Finishes - OfficeChairMainMaterial: Steelcut Trio 1652
Other - Armrest: yes; AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Flokk_OffcChrs_RHMereo200: Mereo 200 Silver; Family and Type: CONV_Flokk_OffcChrs_RHMereo200: Mereo 200 Silver; InstallationDate: n/a; NotArmrest: no; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Flokk_OffcChrs_RHMereo200: Mereo 200 Silver; Type Id: CONV_Flokk_OffcChrs_RHMereo200: Mereo 200 Silver; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Data(Type) - ShareRecyclableMaterials: 96%; ShareRecycledMaterials: 33%
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Flokk_OffcChrs_RHMereo200; ConvergoRefNr: 0119-1802-0028-NO; ExpiringDate: 08/2018; ManufacturerName: Flokk; ManufacturerURL: https://www.flokk.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: RH Mereo 200 has a medium back and comes as standard with castors for carpeted floors and base in grey lacquered aluminium. It can also be enhanced with a range of options such as armrests and coat hanger.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 07/03/2018
Identity Data(Type) - Collection: RH Mereo; Cost: 0; Designer: Veryday; Manufacturer: Flokk; Model: RH Mereo 200 Silver; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Mereo 200 Silver; URL: https://www.flokk.com/rh/products/task-chairs/rh-mereo/8111; Weight: 18.4 kg
Materials and Finishes(Type) - OfficeChairSecondaryMaterial: Plastic, Opaque Black; OffieChairTertiaryMaterial: Silver Metal
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: RH; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Flokk_OffcChrs_RHMereo200; Features: Adjustable seat height, armrest, coat hanger; Finish: Grey lacquered aluminum; Grade: n/a; Material: Textile, metal, plastic; ModelNumber: 8111; ModelReference: n/a; Name: OffcChrs_RHMereo200; ReplacementCost: n/a; Shape: Sculptured; Size: 650x650x818/950mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
