Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-18T01:50:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 18 01:50:36 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{F4A57808-9ECB-4832-9E15-7846961D5EB7}\ifc * Database version: 5507 * Database creation date: Tue Dec 18 01:50:35 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 18 01:50:36 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 18 01:50:36 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Mereo 300 Black, CONV_Flokk_OffcChrs_RHMereo300:Mereo 300 Black:316024
In: Level 1
Material: Steelcut Trio 1652, Plastic, Opaque Black, Black Metal
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Flokk
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 3.87146 m2; Volume: 0.517374 m3
Materials and Finishes - OfficeChairMainMaterial: Steelcut Trio 1652
Other - Armrest: yes; AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Flokk_OffcChrs_RHMereo300: Mereo 300 Black; Family and Type: CONV_Flokk_OffcChrs_RHMereo300: Mereo 300 Black; Headrest: yes; InstallationDate: n/a; NotArmrest: no; NotHeadrest: no; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Flokk_OffcChrs_RHMereo300: Mereo 300 Black; Type Id: CONV_Flokk_OffcChrs_RHMereo300: Mereo 300 Black; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Data(Type) - ShareRecyclableMaterials: 96%; ShareRecycledMaterials: 33%
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Flokk_OffcChrs_RHMereo300; ConvergoRefNr: 0119-1812-0001-NO; ManufacturerName: Flokk; ManufacturerURL: https://www.flokk.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: RH Mereo 300 has a large classic square back and comes as standard with castors for carpeted floors and base in grey lacquered aluminum. It can also be enhanced with a range of options such as armrests and coat hanger.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 17/12/2018
Identity Data(Type) - Collection: RH Mereo; Cost: 0; Manufacturer: Flokk; Model: RH Mereo 300 Black; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Mereo 300 Black; URL: https://www.flokk.com/rh/products/task-chairs/rh-mereo/rh-mereo-300-silver; Weight: 18.9 kg
Materials and Finishes(Type) - OfficeChairSecondaryMaterial: Plastic, Opaque Black; OffieChairTertiaryMaterial: Black Metal
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: RH; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Flokk_OffcChrs_RHMereo300; Features: Adjustable seat height, armrest, coat hanger; Finish: Black lacquered aluminum; Grade: n/a; Material: Textile, metal, plastic; ModelNumber: 8311; ModelReference: n/a; Name: OffcChrs_RHMereo300; ReplacementCost: n/a; Shape: Sculptured; Size: 650x650x1094/1226 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
